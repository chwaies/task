# Keil uVision project test.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\code_base\st_peripheral\Core\Inc;..\..\code_base\st_peripheral\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\code_base\st_peripheral\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\code_base\st_peripheral\Drivers\CMSIS\Include;..\..\code_base\st_peripheral\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\code_base\task_core;..\HARDWARE\Key;..\task_app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../task_app/: main.c task_app.c stm32f4xx_it.c
    ./: startup_stm32f407xx.s
  group Hardware
    ../HARDWARE/Key/: key.c
  group Dirve
    ../../code_base/st_peripheral/Core/Src/: gpio.c stm32f4xx_hal_msp.c system_stm32f4xx.c tim.c usart.c
  group Taskcode
    ../../code_base/task_core/: task.c task_mem.c
  group ST_peripheral
    ../../code_base/st_peripheral/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
