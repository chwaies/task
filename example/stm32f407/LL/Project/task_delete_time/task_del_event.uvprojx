# Keil uVision project task_del_event.uvprojx, settings and files
target task_del_event (6160000::V6.16::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usart
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_LL_Driver\Inc;.\Application\Inc;..\..\c_lirary;..\..\task_mana;.\Application\module\Key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./Application/Src/: main.c stm32f4xx_it.c task_app.c
  group C_library
    ../../c_lirary/: printf.c
  group ST/Drivers/INIT
    ./Application/Src/: app_tim.c app_usart.c
  group HARDWARE/Modlue
    ./Application/module/Key/: key.c
  group Task_mana
    ../../task_mana/: task.c task_mem.c taskconfig.h
  group Drivers/CMSIS_AND_Setup
    ./: startup_stm32f407xx.s
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_LL_Driver
    ../../Drivers/STM32F4xx_LL_Driver/Src/: stm32f4xx_ll_utils.c stm32f4xx_ll_gpio.c stm32f4xx_ll_usart.c stm32f4xx_ll_rcc.c stm32f4xx_ll_tim.c
